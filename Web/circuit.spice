* Auto-generated circuit
.title Simple Circuit Analysis
V1 1 0 5V

.model LED_MODEL D(IS=1e-12 N=2)
.end
